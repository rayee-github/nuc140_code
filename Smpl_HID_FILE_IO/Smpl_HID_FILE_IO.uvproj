# Keil uVision project Smpl_HID_FILE_IO.uvproj, settings and files
target Smpl_HID_FILE_IO (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_HID_FILE_IO
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: .\;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_HID_FILE_IO.c HID_API.c HIDSysIO.c V6MDebug.c SPI_FLASH.c
  group Header files
    ./: HID_API.h HIDSysIO.h V6MDebug.h SPI_FLASH.h
    ../../../Include/NUC1xx-LB_002/: LCD_Driver.h
    ../../USB/Smpl_HID/: HIDSys.h
  group LCD files
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C
  group Library files
    ../../../Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c DrvUSB.c retarget.c DrvSPI.c DrvPDMA.c
    ../../USB/Smpl_HID/: HIDSys.c
