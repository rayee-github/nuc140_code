# Keil uVision project Smpl_VCOM_USB2UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC100RD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_VCOM_USB2UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\bin\@L.bin"
  c flags: Optim=4 OneElfS=1
  c include: ..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include\Driver;..\..\..\Include;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source
    ./: VCOM_API.c Smpl_VCOM_USB2UART.c
