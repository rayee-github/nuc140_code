# Keil uVision project Smpl_CDROM_HID.uvproj, settings and files
target Smpl_CDROM_HID (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_CDROM_HID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_CDROM_HID.c spiProg.c CDROM_HID_API.c V6MDebug.c
  group Header files
    ./: V6MDebug.h spiProg.h
    ../../../Include/NUC1xx-LB_002/: LCD_Driver.h
  group LCD files
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C
  group Library files
    ../../../Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c DrvUSB.c retarget.c DrvSPI.c DrvPDMA.c
    ./: CDROMHIDSys.c
