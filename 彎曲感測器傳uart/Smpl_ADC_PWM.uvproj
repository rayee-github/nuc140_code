# Keil uVision project Smpl_ADC_PWM.uvproj, settings and files
target Smpl_ADC_PWM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_ADC_PWM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_ADC_PWM.c
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C
    ../../../Src/Driver/: DrvUART.c DrvSYS.c
  group Library files
    ../../../Src/Driver/: DrvGPIO.c DrvADC.c
