# Keil uVision project a.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: control
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./objects/bin/control.bin ./objects/control.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: startup_NUC1xx.s
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group Source files
    ./: control.c
  group Library files
    ../../../Src/Driver/: DrvADC.c DrvGPIO.c DrvSYS.c DrvUART.c
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C
